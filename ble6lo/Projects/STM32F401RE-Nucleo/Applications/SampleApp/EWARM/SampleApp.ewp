# IAR project SampleApp.ewp, settings and files
configuration SampleApp (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BLE_ADDR_RANDOM_GENAUTO; PING_DEBUG=LWIP_DBG_ON; DEBUG=0; SERVER_ROLE; SPI_MODE_DMA; USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/BlueNRG-MS/includes/; ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/; ../../../../../Middlewares/ST/BlueNRG-MS/utils/; ..\..\..\..\..\Middlewares\Third_Party\lwip\src\include; ..\..\..\..\..\Middlewares\Third_Party\lwip\src\include\arch; ..\..\..\..\..\Middlewares\Third_Party\lwip\src\netif\mch; ..\..\..\..\..\Middlewares\Third_Party\lwip\system\arch; ..\..\..\..\..\Middlewares\Third_Party\lwip\src\apps\ping; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\lib\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SampleApp_ROLE_F401RE.bin
  ILINK.IlinkOutputFile: SampleApp.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: app_x-cube-ble1.c app_x-cube-ble1_6lo.c hci_tl_interface.c main.c nucleo_f401re_bus.c sample_service.c stm32f4_nucleo_f401re.c stm32f4xx_hal_exti.c stm32f4xx_hal_msp.c stm32f4xx_it.c tcp_echoclient.c
    ../../../../../Middlewares/Third_Party/lwip/src/apps/ping/: ping6.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/Third_Party/lwip/minimal
    ../../../../../Middlewares/Third_Party/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Third_Party/lwip/system
    ../../../../../Middlewares/Third_Party/lwip/system/OS/: sys_arch.c
  group Middlewares/X-CUBE-BLE1/Wireless/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_IFR.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/X-CUBE-BLE1/Wireless/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/X-CUBE-BLE1/Wireless/Lib
    ../../../../../Middlewares/ST/BlueNRG-MS/lib/: bt_6lowpan.a
  group Middlewares/X-CUBE-BLE1/Wireless/Lib/ble
    ../../../../../../lib_ble6lowpan/Projects/STM32F401RE-Nucleo/Lib/bt_6lowpan/Src/: app_x-cube-ble1_6lo_ex.c bluenrg_6lo_ip.c bluenrg_6lo_l2cap_aci.c hci_tl_6lo.c hci_tl_interface_6lo.c nucleo_f401re_bus.c sample_service_6lo.c stm32f4xx_hal_msp.c
  group Middlewares/X-CUBE-BLE1/Wireless/Lib/ipv6
    ../../../../../../lib_ble6lowpan/Middlewares/Third_Party/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group Middlewares/X-CUBE-BLE1/Wireless/Lib/netif
    ../../../../../../lib_ble6lowpan/Middlewares/Third_Party/lwip/src/netif/: lowpan6.c lowpan6_ble.c lowpan6_common.c
  group Middlewares/X-CUBE-BLE1/Wireless/Lib/netif/mch
    ../../../../../../lib_ble6lowpan/Middlewares/Third_Party/lwip/src/netif/mch/: mch_main.c
  group Middlewares/X-CUBE-BLE1/Wireless/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
